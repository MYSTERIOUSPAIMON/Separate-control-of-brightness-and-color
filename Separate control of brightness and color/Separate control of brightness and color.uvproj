# Keil uVision project Separate control of brightness and color.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8H1K28 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x03FF) IROM(0-0x6FF8) CLOCK(35000000) MODP2
  output: Separate control of brightness and color +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 Separate control.c __STC8H_H__.h
